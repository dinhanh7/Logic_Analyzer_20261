/* la-signal-gen: test signal generator for the RP2350 logic analyzer.
 *
 * Every signal here has a known timing so a capture can be checked against a
 * reference. All levels are 3.3 V, so they go straight into the LA probes.
 *
 *   SQ      square wave, 50 % duty, generated by LEDC
 *   SQ2     same timer, 25 % duty -> a known two channel pattern
 *   PAT0-3  four channels of one timer with 12.5/25/37.5/50 % duty ->
 *           a known four bit pattern that repeats every period
 *   I2C     two bit banged lines that emit a complete transaction
 *   SPI     hardware master that sends a fixed frame
 *   UART    115200 8N1 stream with a fixed text
 *
 * The console is UART0 (USB serial/JTAG), the signal UART is UART1.
 */
#include <inttypes.h>
#include <stdarg.h>
#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#include "driver/gpio.h"
#include "driver/ledc.h"
#include "driver/spi_master.h"
#include "driver/twai.h"
#include "driver/uart.h"
#include "esp_rom_sys.h"
#include "freertos/FreeRTOS.h"
#include "freertos/semphr.h"
#include "freertos/task.h"

/* Pin map. ESP32 DevKitC (38 pin): avoid 0,2,5,12,15 (strapping)
 * and 6-11 (flash). All pins below are safe general-purpose GPIOs.
 *   SQ      4    SQ2     25
 *   PAT0-3  13,14,16,17
 *   I2C     18 SCL, 19 SDA
 *   SPI     21 CS, 22 SCK, 23 MOSI, 25 MISO
 *   UART    26 TX, 27 RX  (TX goes to Pico GP6 if you want to test UART decode)
 */
#define PIN_SQ        4
#define PIN_SQ2       25
#define PIN_PAT0      13
#define PIN_PAT1      14
#define PIN_PAT2      16
#define PIN_PAT3      17
#define PIN_I2C_SCL   18
#define PIN_I2C_SDA   19
#define PIN_SPI_CS    21
#define PIN_SPI_SCK   22
#define PIN_SPI_MOSI  23
#define PIN_SPI_MISO  25
#define PIN_UART_TX   26
#define PIN_UART_RX   27
#define PIN_CAN_TX   32
#define PIN_CAN_RX   33

#define SIG_PORT      UART_NUM_1
#define SIG_BAUD      115200
#define CONSOLE_PORT  UART_NUM_0

/* LEDC channels: SQ, SQ2 on timer 0; PAT0..PAT3 on timer 1. */
#define TIMER_SQ      LEDC_TIMER_0
#define TIMER_PAT     LEDC_TIMER_1
#define CH_SQ         LEDC_CHANNEL_0
#define CH_SQ2        LEDC_CHANNEL_1
#define CH_PAT0       LEDC_CHANNEL_0

/* Duty of PAT0..PAT3 as a fraction of the period. With a 4 bit resolution
 * they are 2/16, 4/16, 6/16 and 8/16, so the four channels show four
 * different levels in a quarter of the period. */
static const uint32_t pat_duty[4] = {2, 4, 6, 8};
static const ledc_timer_bit_t pat_res = LEDC_TIMER_4_BIT;

/* Bit banged I2C. The half period is a console setting so the analyzer can be
 * swept from 100 kHz up to the point where the bit banging gives up. */
#define I2C_SLAVE_ADDR    0x68
#define I2C_SLAVE_REG     0x01
#define I2C_SLAVE_DATA    0x5a

/* SPI frame sent every 100 ms. The clock is a console setting. */
static const uint8_t spi_frame[8] = {0xde, 0xad, 0xbe, 0xef, 0x00, 0x01, 0x02, 0x03};

static uint32_t target_hz = 1000;
static uint32_t actual_hz = 0;
static ledc_timer_bit_t sq_res = LEDC_TIMER_14_BIT;
static bool uart_stream = true;
static uint32_t sig_baud = 115200;
static uint32_t i2c_half_us = 5;      /* 100 kHz */
static uint32_t spi_hz = 1000000;
static uint32_t can_kbps = 250;
/* Burst mode: emit one CAN frame, one UART message, one I2C transaction and
 * one SPI frame back to back every 100 ms, so a single 25 MHz logic analyzer
 * window can carry all four protocols at once. */
static bool burst_mode = true;
static spi_device_handle_t g_spi_dev;
static bool g_spi_ok;
static SemaphoreHandle_t g_spi_mtx;
static SemaphoreHandle_t g_can_mtx;
static bool g_can_ready;
static twai_message_t g_can_msg;

/* ---------------------------------------------------------------- helpers */

/* CONFIG_FREERTOS_HZ is 100, so pdMS_TO_TICKS(5) rounds to 0 and a task would
 * spin instead of sleeping. Never hand vTaskDelay a zero tick count. */
#define DELAY_MS(ms) do { TickType_t _t = pdMS_TO_TICKS(ms); vTaskDelay(_t ? _t : 1); } while (0)

static void console(const char *fmt, ...)
{
    char buf[256];
    va_list ap;
    va_start(ap, fmt);
    int n = vsnprintf(buf, sizeof(buf), fmt, ap);
    va_end(ap);
    if (n > 0) uart_write_bytes(CONSOLE_PORT, buf, (size_t)n);
}

/* Configure the square timer and report the frequency the hardware really
 * produces. The LEDC divider is not continuous, so the request is rounded and
 * the achieved value is what the LA has to be compared with. */
static void set_square_frequency(uint32_t hz)
{
    target_hz = hz;
    ledc_timer_config_t timer = {
        .speed_mode = LEDC_LOW_SPEED_MODE,
        .timer_num = TIMER_SQ,
        .duty_resolution = sq_res,
        .freq_hz = hz,
        .clk_cfg = LEDC_AUTO_CLK,
    };
    ESP_ERROR_CHECK(ledc_timer_config(&timer));
    actual_hz = ledc_get_freq(LEDC_LOW_SPEED_MODE, TIMER_SQ);
    /* The pattern timer runs at the same rate. */
    ledc_timer_config_t ptimer = {
        .speed_mode = LEDC_LOW_SPEED_MODE,
        .timer_num = TIMER_PAT,
        .duty_resolution = pat_res,
        .freq_hz = actual_hz,
        .clk_cfg = LEDC_AUTO_CLK,
    };
    ESP_ERROR_CHECK(ledc_timer_config(&ptimer));
    console("square: requested %" PRIu32 " Hz, hardware %" PRIu32 " Hz (resolution %d bit)\n",
            hz, actual_hz, (int)sq_res);
}

/* Look for the duty resolution that lands closest to the requested frequency.
 * Some combinations are exact, for example 1 kHz needs 7 bit and 1 MHz needs
 * 4 bit with an 80 MHz APB clock. */
static void auto_resolution(uint32_t hz)
{
    static const ledc_timer_bit_t options[] = {
        LEDC_TIMER_14_BIT, LEDC_TIMER_13_BIT, LEDC_TIMER_12_BIT, LEDC_TIMER_11_BIT,
        LEDC_TIMER_10_BIT, LEDC_TIMER_9_BIT, LEDC_TIMER_8_BIT, LEDC_TIMER_7_BIT,
        LEDC_TIMER_6_BIT, LEDC_TIMER_5_BIT, LEDC_TIMER_4_BIT,
    };
    uint32_t best_err = UINT32_MAX;
    ledc_timer_bit_t best = sq_res;
    for (size_t i = 0; i < sizeof(options) / sizeof(options[0]); i++) {
        ledc_timer_config_t timer = {
            .speed_mode = LEDC_LOW_SPEED_MODE,
            .timer_num = TIMER_SQ,
            .duty_resolution = options[i],
            .freq_hz = hz,
            .clk_cfg = LEDC_AUTO_CLK,
        };
        if (ledc_timer_config(&timer) != ESP_OK) continue;
        uint32_t got = ledc_get_freq(LEDC_LOW_SPEED_MODE, TIMER_SQ);
        uint32_t err = got > hz ? got - hz : hz - got;
        if (err < best_err) { best_err = err; best = options[i]; }
    }
    sq_res = best;
    set_square_frequency(hz);
}

static void configure_ledc_channel(int gpio, ledc_timer_t timer, ledc_channel_t channel,
                                   uint32_t duty)
{
    ledc_channel_config_t ch = {
        .gpio_num = gpio,
        .speed_mode = LEDC_LOW_SPEED_MODE,
        .channel = channel,
        .intr_type = LEDC_INTR_DISABLE,
        .timer_sel = timer,
        .duty = duty,
        .hpoint = 0,
        .sleep_mode = LEDC_SLEEP_MODE_NO_ALIVE_NO_PD,
    };
    ESP_ERROR_CHECK(ledc_channel_config(&ch));
    ESP_ERROR_CHECK(ledc_update_duty(LEDC_LOW_SPEED_MODE, channel));
}

/* --------------------------------------------------------------- bit I2C */

/* One data bit: the level is set while the clock is low, then the clock is
 * pulsed. The LA samples on the rising edge, so the level is already stable. */
static void i2c_bit(int level)
{
    gpio_set_level(PIN_I2C_SDA, level);
    esp_rom_delay_us(i2c_half_us);
    gpio_set_level(PIN_I2C_SCL, 1);
    esp_rom_delay_us(i2c_half_us);
    gpio_set_level(PIN_I2C_SCL, 0);
}

/* A byte plus the acknowledge slot. There is no real slave on the bus, so the
 * acknowledge is produced by pulling SDA low for the ninth clock, exactly as a
 * slave would. */
static void i2c_byte(uint8_t value)
{
    for (int i = 7; i >= 0; i--) i2c_bit((value >> i) & 1);
    i2c_bit(0);
}

static void i2c_start(void)
{
    gpio_set_level(PIN_I2C_SCL, 1);
    gpio_set_level(PIN_I2C_SDA, 1);
    esp_rom_delay_us(i2c_half_us);
    gpio_set_level(PIN_I2C_SDA, 0);      /* SDA falls while SCL is high */
    esp_rom_delay_us(i2c_half_us);
    gpio_set_level(PIN_I2C_SCL, 0);
}

static void i2c_stop(void)
{
    gpio_set_level(PIN_I2C_SDA, 0);
    esp_rom_delay_us(i2c_half_us);
    gpio_set_level(PIN_I2C_SCL, 1);
    esp_rom_delay_us(i2c_half_us);
    gpio_set_level(PIN_I2C_SDA, 1);      /* SDA rises while SCL is high */
    esp_rom_delay_us(i2c_half_us);
}

static void i2c_transaction(void)
{
    i2c_start();
    i2c_byte((uint8_t)(I2C_SLAVE_ADDR << 1));   /* write */
    i2c_byte(I2C_SLAVE_REG);
    i2c_byte(I2C_SLAVE_DATA);
    i2c_stop();
}

/* ----------------------------------------------------------------- tasks */

static void i2c_task(void *arg)
{
    (void)arg;
    while (true) {
        if (!burst_mode) i2c_transaction();
        DELAY_MS(100);
    }
}

static void spi_send_frame(void)
{
    uint8_t rx[sizeof(spi_frame)];
    spi_transaction_t t = {
        .length = sizeof(spi_frame) * 8,
        .tx_buffer = spi_frame,
        .rx_buffer = rx,
    };
    if (!g_spi_ok) return;
    xSemaphoreTake(g_spi_mtx, portMAX_DELAY);
    spi_device_polling_transmit(g_spi_dev, &t);
    xSemaphoreGive(g_spi_mtx);
}

static void spi_task(void *arg)
{
    (void)arg;
    while (true) {
        if (!burst_mode) spi_send_frame();
        DELAY_MS(100);
    }
}

static void uart_task(void *arg)
{
    (void)arg;
    static const char message[] = "LA1234\n";
    while (true) {
        if (!burst_mode && uart_stream)
            uart_write_bytes(SIG_PORT, message, sizeof(message) - 1);
        DELAY_MS(5);
    }
}

/* Install the TWAI driver once. NO-ACK self-test with TX and RX on the same
 * pin gives a valid bit stream without a transceiver or a jumper. */
static bool can_install(uint32_t kbps)
{
    /* The ESP32 TWAI prescaler register stores brp/2 - 1 (so brp must be
     * even; above 128 it must be a multiple of 4 for the brp_div bit) and
     * tseg1 is only 4 bits wide, so the bit time is 1 + tseg1 + tseg2 <= 20
     * quanta. Pick a prescaler from the 80 MHz APB clock that fits. */
    uint32_t cycles = 80000000u / (kbps * 1000u);
    uint32_t brp = 0, quanta = 20;
    for (uint32_t b = 2; b <= 256; b += 2) {
        if (b > 128 && (b % 4)) continue;
        if (cycles % b) continue;
        uint32_t q = cycles / b;
        if (q >= 8 && q <= 20) { brp = b; quanta = q; break; }
    }
    if (!brp) {
        console("CAN: %" PRIu32 " kbps is not reachable from the 80 MHz APB clock\n", kbps);
        return false;
    }
    twai_general_config_t g_config = TWAI_GENERAL_CONFIG_DEFAULT(PIN_CAN_TX, PIN_CAN_TX, TWAI_MODE_NO_ACK);
    twai_timing_config_t t_config = {
        .clk_src = TWAI_CLK_SRC_DEFAULT,
        .quanta_resolution_hz = 80000000u / brp,
        .brp = 0,
        .prop_seg = 0,
        .tseg_1 = quanta - 5,   /* 1 sync + tseg1 + 4 tseg2 = quanta */
        .tseg_2 = 4,
        .sjw = 3,
        .ssp_offset = 0,
        .triple_sampling = false,
    };
    twai_filter_config_t f_config = TWAI_FILTER_CONFIG_ACCEPT_ALL();
    esp_err_t err = twai_driver_install(&g_config, &t_config, &f_config);
    if (err == ESP_OK) err = twai_start();
    if (err != ESP_OK) {
        console("CAN: setup failed: %s\n", esp_err_to_name(err));
        return false;
    }
    g_can_msg.extd = 0;
    g_can_msg.rtr = 0;
    g_can_msg.ss = 1;
    g_can_msg.data_length_code = 4;
    g_can_msg.identifier = 0x123;
    g_can_msg.data[0] = 0xDE; g_can_msg.data[1] = 0xAD;
    g_can_msg.data[2] = 0xBE; g_can_msg.data[3] = 0xEF;
    g_can_ready = true;
    return true;
}

/* Stop, uninstall and reinstall the driver at another bit rate. */
static bool can_set_rate(uint32_t kbps)
{
    bool ok;
    xSemaphoreTake(g_can_mtx, portMAX_DELAY);
    g_can_ready = false;
    twai_stop();
    twai_driver_uninstall();
    ok = can_install(kbps);
    if (ok) can_kbps = kbps;
    xSemaphoreGive(g_can_mtx);
    return ok;
}

static void can_send_once(void)
{
    xSemaphoreTake(g_can_mtx, portMAX_DELAY);
    if (g_can_ready) {
        twai_transmit(&g_can_msg, pdMS_TO_TICKS(20));
        g_can_msg.data[0]++; g_can_msg.data[1]++;
        g_can_msg.data[2]++; g_can_msg.data[3]++;
    }
    xSemaphoreGive(g_can_mtx);
}

static void can_task(void *arg)
{
    (void)arg;
    bool reported = false;
    while (true) {
        if (!burst_mode) {
            can_send_once();
            if (!reported) {
                console("CAN: first frame 0x123 queued\n");
                reported = true;
            }
        }
        DELAY_MS(100);
    }
}

/* All four protocols in one short burst: CAN frame ~0.3 ms, UART "LA1234\n"
 * 0.61 ms, I2C transaction 0.27 ms, SPI frame 64 us. Back to back this fits
 * inside a 1.6 ms window (40000 samples at 25 MHz). */
static void burst_task(void *arg)
{
    (void)arg;
    while (true) {
        if (burst_mode) {
            can_send_once();
            uart_write_bytes(SIG_PORT, "LA1234\n", 7);
            i2c_transaction();
            spi_send_frame();
        }
        DELAY_MS(100);
    }
}

/* Read a line from the console UART. */
static void read_line(char *buf, size_t len, TickType_t timeout)
{
    size_t n = 0;
    TickType_t start = xTaskGetTickCount();
    while (n + 1 < len) {
        uint8_t c;
        int got = uart_read_bytes(CONSOLE_PORT, &c, 1, pdMS_TO_TICKS(50));
        if (got == 1) {
            if (c == '\r' || c == '\n') break;
            buf[n++] = (char)c;
        } else if ((xTaskGetTickCount() - start) > timeout) {
            break;
        }
    }
    buf[n] = '\0';
}

static void print_status(void)
{
    console("status:\n");
    console("  SQ      GPIO %d  %" PRIu32 " Hz hardware (asked %" PRIu32 " Hz), 50 %% duty\n",
            PIN_SQ, actual_hz, target_hz);
    console("  SQ2     GPIO %d  same timer, 25 %% duty\n", PIN_SQ2);
    console("  PAT0-3  GPIO %d,%d,%d,%d  12.5/25/37.5/50 %% duty, same period\n",
            PIN_PAT0, PIN_PAT1, PIN_PAT2, PIN_PAT3);
    console("  I2C     GPIO %d SCL, %d SDA  %" PRIu32 " kHz, write %02X reg %02X data %02X\n",
            PIN_I2C_SCL, PIN_I2C_SDA, 500 / i2c_half_us,
            I2C_SLAVE_ADDR, I2C_SLAVE_REG, I2C_SLAVE_DATA);
    console("  SPI     GPIO %d CS, %d SCK, %d MOSI, %d MISO  %" PRIu32 " Hz, frame DE AD BE EF 00 01 02 03\n",
            PIN_SPI_CS, PIN_SPI_SCK, PIN_SPI_MOSI, PIN_SPI_MISO, spi_hz);
    console("  UART    GPIO %d TX at %" PRIu32 " baud, %s\n", PIN_UART_TX, sig_baud,
            uart_stream ? "sending \"LA1234\\n\" every 5 ms" : "paused");
    console("  CAN     GPIO %d TX @%" PRIu32 " kbps, ID 0x123, data DE AD BE EF (incrementing)\n",
            PIN_CAN_TX, can_kbps);
    console("  mode    %s\n", burst_mode
            ? "burst: all four protocols together every 100 ms"
            : "independent: each protocol every 100 ms");
}

static void help(void)
{
    console("commands:\n");
    console("  freq <hz>      set the square wave frequency, best resolution is picked\n");
    console("  uart on|off    start or pause the UART stream\n");
    console("  set uart <baud>  change the signal UART bit rate (300..5000000)\n");
    console("  set i2c <khz>    change the bit banged I2C clock (4..500 kHz)\n");
    console("  set spi <khz>    change the SPI clock (100..40000 kHz)\n");
    console("  set can <kbps>   change the CAN bit rate (10..1000 kbps), driver reload\n");
    console("  burst on|off   all four protocols in one burst, or independent 100 ms tasks\n");
    console("  status         print the current signals and the real frequencies\n");
    console("  help           this list\n");
    console("  Note: CAN uses TWAI in NO-ACK self-test mode (no transceiver needed).\n");
    console("  Note: 'set' changes take effect on the next transmission, no reboot.\n");
}

/* Apply one `set <name> <value>` line. */
static bool set_command(const char *line)
{
    const char *name = line + 4;
    const char *sp = strchr(name, ' ');
    if (!sp) return false;
    size_t nlen = (size_t)(sp - name);
    uint32_t value = (uint32_t)strtoul(sp + 1, NULL, 10);

    if (nlen == 4 && strncmp(name, "uart", 4) == 0) {
        if (value < 300 || value > 5000000) {
            console("uart: 300..5000000 baud\n");
            return true;
        }
        esp_err_t err = uart_set_baudrate(SIG_PORT, value);
        if (err != ESP_OK) {
            console("uart: rejected: %s\n", esp_err_to_name(err));
            return true;
        }
        sig_baud = value;
        console("uart: %" PRIu32 " baud\n", sig_baud);
    } else if (nlen == 3 && strncmp(name, "i2c", 3) == 0) {
        if (value < 4 || value > 500) {
            console("i2c: 4..500 kHz\n");
            return true;
        }
        i2c_half_us = 500 / value;
        console("i2c: %" PRIu32 " kHz (half period %" PRIu32 " us, real %.1f kHz)\n",
                value, i2c_half_us, 500.0 / i2c_half_us);
    } else if (nlen == 3 && strncmp(name, "spi", 3) == 0) {
        /* SPI2 is fed from the 80 MHz APB clock and needs an integer divider,
         * so 26.6 MHz is the ceiling (80/3). */
        if (value < 100 || value > 26666) {
            console("spi: 100..26666 kHz (80 MHz / 3 max)\n");
            return true;
        }
        spi_device_interface_config_t cfg = {
            .clock_speed_hz = (int)(value * 1000u),
            .mode = 0,
            .spics_io_num = PIN_SPI_CS,
            .queue_size = 1,
        };
        xSemaphoreTake(g_spi_mtx, portMAX_DELAY);
        spi_bus_remove_device(g_spi_dev);
        esp_err_t err = spi_bus_add_device(SPI2_HOST, &cfg, &g_spi_dev);
        if (err != ESP_OK) {
            /* Put the old device back so the burst task keeps a live handle. */
            spi_device_interface_config_t back = {
                .clock_speed_hz = (int)spi_hz,
                .mode = 0,
                .spics_io_num = PIN_SPI_CS,
                .queue_size = 1,
            };
            esp_err_t back_err = spi_bus_add_device(SPI2_HOST, &back, &g_spi_dev);
            g_spi_ok = (back_err == ESP_OK);
            xSemaphoreGive(g_spi_mtx);
            console("spi: %" PRIu32 " kHz rejected (%s)%s\n", value,
                    esp_err_to_name(err),
                    back_err == ESP_OK ? ", kept the old clock" : ", SPI STOPPED");
            return true;
        }
        g_spi_ok = true;
        xSemaphoreGive(g_spi_mtx);
        spi_hz = value * 1000u;
        console("spi: %" PRIu32 " Hz\n", spi_hz);
    } else if (nlen == 3 && strncmp(name, "can", 3) == 0) {
        if (value < 10 || value > 1000) {
            console("can: 10..1000 kbps\n");
            return true;
        }
        if (can_set_rate(value)) console("can: %" PRIu32 " kbps\n", can_kbps);
    } else {
        return false;
    }
    return true;
}

/* ------------------------------------------------------------------- main */

void app_main(void)
{
    const uart_config_t console_cfg = {
        .baud_rate = 115200,
        .data_bits = UART_DATA_8_BITS,
        .parity = UART_PARITY_DISABLE,
        .stop_bits = UART_STOP_BITS_1,
        .flow_ctrl = UART_HW_FLOWCTRL_DISABLE,
        .source_clk = UART_SCLK_DEFAULT,
    };
    ESP_ERROR_CHECK(uart_driver_install(CONSOLE_PORT, 256, 256, 0, NULL, 0));
    ESP_ERROR_CHECK(uart_param_config(CONSOLE_PORT, &console_cfg));

    const uart_config_t sig_cfg = {
        .baud_rate = sig_baud,
        .data_bits = UART_DATA_8_BITS,
        .parity = UART_PARITY_DISABLE,
        .stop_bits = UART_STOP_BITS_1,
        .flow_ctrl = UART_HW_FLOWCTRL_DISABLE,
        .source_clk = UART_SCLK_DEFAULT,
    };
    ESP_ERROR_CHECK(uart_driver_install(SIG_PORT, 256, 1024, 0, NULL, 0));
    ESP_ERROR_CHECK(uart_param_config(SIG_PORT, &sig_cfg));
    ESP_ERROR_CHECK(uart_set_pin(SIG_PORT, PIN_UART_TX, PIN_UART_RX, UART_PIN_NO_CHANGE,
                                 UART_PIN_NO_CHANGE));

    /* The two I2C lines are plain GPIOs, driven push pull because no real
     * slave shares the bus. */
    const int i2c_pins[] = {PIN_I2C_SCL, PIN_I2C_SDA};
    for (size_t i = 0; i < sizeof(i2c_pins) / sizeof(i2c_pins[0]); i++) {
        gpio_config_t io = {
            .pin_bit_mask = 1ULL << i2c_pins[i],
            .mode = GPIO_MODE_OUTPUT,
            .pull_up_en = GPIO_PULLUP_DISABLE,
            .pull_down_en = GPIO_PULLDOWN_DISABLE,
            .intr_type = GPIO_INTR_DISABLE,
        };
        ESP_ERROR_CHECK(gpio_config(&io));
    }
    gpio_set_level(PIN_I2C_SCL, 1);
    gpio_set_level(PIN_I2C_SDA, 1);

    auto_resolution(target_hz);
    configure_ledc_channel(PIN_SQ, TIMER_SQ, CH_SQ, 1u << (sq_res - 1));
    configure_ledc_channel(PIN_SQ2, TIMER_SQ, CH_SQ2, 1u << (sq_res - 2));
    const int pat_pins[4] = {PIN_PAT0, PIN_PAT1, PIN_PAT2, PIN_PAT3};
    for (int i = 0; i < 4; i++) {
        configure_ledc_channel(pat_pins[i], TIMER_PAT, (ledc_channel_t)(CH_PAT0 + i),
                               pat_duty[i]);
    }

    spi_bus_config_t bus = {
        .mosi_io_num = PIN_SPI_MOSI,
        .miso_io_num = PIN_SPI_MISO,
        .sclk_io_num = PIN_SPI_SCK,
        .quadwp_io_num = -1,
        .quadhd_io_num = -1,
    };
    ESP_ERROR_CHECK(spi_bus_initialize(SPI2_HOST, &bus, SPI_DMA_CH_AUTO));
    spi_device_interface_config_t spi_dev_cfg = {
        .clock_speed_hz = spi_hz,
        .mode = 0,
        .spics_io_num = PIN_SPI_CS,
        .queue_size = 1,
    };
    spi_device_handle_t spi_dev;
    ESP_ERROR_CHECK(spi_bus_add_device(SPI2_HOST, &spi_dev_cfg, &spi_dev));
    g_spi_dev = spi_dev;
    g_spi_ok = true;
    g_spi_mtx = xSemaphoreCreateMutex();
    g_can_mtx = xSemaphoreCreateMutex();
    if (!g_spi_mtx || !g_can_mtx) {
        console("mutex allocation failed\n");
        return;
    }
    can_install(can_kbps);

    xTaskCreate(i2c_task, "i2c_task", 3072, NULL, 5, NULL);
    xTaskCreate(spi_task, "spi_task", 3072, NULL, 5, NULL);
    xTaskCreate(uart_task, "uart_task", 3072, NULL, 5, NULL);
    xTaskCreate(can_task, "can_task", 4096, NULL, 5, NULL);
    xTaskCreate(burst_task, "burst_task", 4096, NULL, 6, NULL);

    console("\n=== la-signal-gen for the RP2350 logic analyzer ===\n");
    console("all levels are 3.3 V, connect the grounds of both boards\n");
    console("tie GPIO %d to GPIO %d with a jumper so MISO shows the same bytes as MOSI\n",
            PIN_SPI_MOSI, PIN_SPI_MISO);
    print_status();
    console("\ntype 'help' for the command list\n");

    char line[128];
    while (true) {
        read_line(line, sizeof(line), pdMS_TO_TICKS(200));
        if (line[0] == '\0') continue;
        console("> %s\n", line);
        if (strncmp(line, "freq", 4) == 0 && line[4] == ' ') {
            auto_resolution((uint32_t)strtoul(line + 5, NULL, 10));
            /* The duty has to follow the new resolution. */
            configure_ledc_channel(PIN_SQ, TIMER_SQ, CH_SQ, 1u << (sq_res - 1));
            configure_ledc_channel(PIN_SQ2, TIMER_SQ, CH_SQ2, 1u << (sq_res - 2));
        } else if (strcmp(line, "uart on") == 0) {
            uart_stream = true;
        } else if (strcmp(line, "uart off") == 0) {
            uart_stream = false;
        } else if (strcmp(line, "burst on") == 0) {
            burst_mode = true;
        } else if (strcmp(line, "burst off") == 0) {
            burst_mode = false;
        } else if (strncmp(line, "set ", 4) == 0) {
            if (!set_command(line)) console("unknown set target, type 'help'\n");
        } else if (strcmp(line, "status") == 0) {
            print_status();
        } else if (strcmp(line, "help") == 0) {
            help();
        } else {
            console("unknown command, type 'help'\n");
        }
    }
}
